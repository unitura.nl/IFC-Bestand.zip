Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (1)\Producten\1. Faunavoorzieningen\1. Houten voorzieningen\XPS KASTEN\VMPW2\2. Tekeningen en documentatie\1. Brontekeningen\VMPW2-01.IFC
Time: 2025-02-05T12:01:24+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
